# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\ADC;..\HARDWARE\AdvancedTim;..\HARDWARE\i2c;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\SysTick;..\HARDWARE\SysTick;.\OLED0561;..\HARDWARE\usart;..\HARDWARE\iwdg;..\HARDWARE\vofa;..\HARDWARE\queue
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./OLED0561/: OLED_I2C2.c
  group HARDWARE
    ../HARDWARE/ADC/: bsp_adc.c
    ../HARDWARE/AdvancedTim/: bsp_advanced_timer.c
    ../HARDWARE/i2c/: bsp_i2c_gpio.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/SysTick/: bsp_systick.c
    ../HARDWARE/LED/: bsp_led.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/iwdg/: iwdg.c
    ../HARDWARE/vofa/: vafa.c
    ../HARDWARE/queue/: queue.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
